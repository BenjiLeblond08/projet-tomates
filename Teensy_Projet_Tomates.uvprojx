# Keil uVision project Teensy_Projet_Tomates.uvprojx, settings and files
target Teensy_Projet_Tomates (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: MK20DX256xxx7 NXP
  pack: Keil.Kinetis_K20_DFP.1.3.0
  cpu: CPUTYPE("Cortex-M4")
  output: Teensy_Projet_Tomates +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c misc: -DDEVICE_RTC=1 -DTARGET_K20XX -DDEVICE_SLEEP=1 -DTOOLCHAIN_object -DTOOLCHAIN_ARM_STD --preinclude=mbed_config.h -DDEVICE_SEMIHOST=1 -D__ASSERT_MSG -DTARGET_RELEASE --no_rtti -DDEVICE_PORTINOUT=1 -c -DTARGET_RTOS_M4_M7 -DDEVICE_SPISLAVE=1 -DDEVICE_PORTOUT=1 -DDEVICE_STDIO_MESSAGES=1 -DDEVICE_ANALOGOUT=1 --split_sections -DDEVICE_I2C=1 -DTARGET_M4 -DDEVICE_ANALOGIN=1 -DTARGET_LIKE_CORTEX_M4 -DTARGET_K20DX256 -D__CORTEX_M4 -DDEVICE_ERROR_RED=1 -DTARGET_CORTEX_M --cpu=Cortex-M4 -DARM_MATH_CM4 -DTARGET_Freescale -DTARGET_TEENSY3_1 -DDEVICE_PORTIN=1 -DTOOLCHAIN_ARM -DDEVICE_I2CSLAVE=1 --no_depend_system_headers -DTARGET_UVISOR_UNSUPPORTED --md -DDEVICE_PWMOUT=1 -DTARGET_LIKE_MBED --gnu --apcs=interwork -DDEVICE_SPI=1 -D__MBED__=1 -DMBED_BUILD_TIMESTAMP=1497460668.99 -DDEVICE_SERIAL=1 -DDEVICE_INTERRUPTIN=1 -D__CMSIS_RTOS -D__MBED_CMSIS_RTOS_CM
  c include: .;mbed-src;mbed-src/hal;mbed-src/api;mbed-src/targets;mbed-src/targets/hal;mbed-src/targets/hal/TARGET_Freescale;mbed-src/targets/hal/TARGET_Freescale/TARGET_K20XX;mbed-src/targets/hal/TARGET_Freescale/TARGET_K20XX/TARGET_TEENSY3_1;mbed-src/targets/cmsis;mbed-src/targets/cmsis/TARGET_Freescale;mbed-src/targets/cmsis/TARGET_Freescale/TARGET_K20XX;mbed-src/targets/cmsis/TARGET_Freescale/TARGET_K20XX/TARGET_TEENSY3_1;mbed-src/targets/cmsis/TARGET_Freescale/TARGET_K20XX/TARGET_TEENSY3_1/TOOLCHAIN_ARM_STD;mbed-src/common; WakeUp; WakeUp/Device; WakeUp/Device/LPC1114_WakeInterruptIn;
  asm misc: --cpreproc --cpreproc_opts=-D__ASSERT_MSG,-D__CMSIS_RTOS,-D__MBED_CMSIS_RTOS_CM,-DARM_MATH_CM4,-D__CORTEX_M4
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  memory RVCT10: RAM 0x1fffe000 size 0x2000
  scatter file: mbed-src/targets/cmsis/TARGET_Freescale/TARGET_K20XX/TARGET_TEENSY3_1/TOOLCHAIN_ARM_STD/MK20DX256.sct
  group mbed-src
    mbed-src/api/: AnalogIn.h AnalogOut.h BusIn.h BusInOut.h BusOut.h CallChain.h CAN.h can_helper.h CircularBuffer.h CThunk.h DigitalIn.h DigitalInOut.h DigitalOut.h DirHandle.h Ethernet.h FileBase.h FileHandle.h FileLike.h FilePath.h FileSystemLike.h FunctionPointer.h I2C.h I2CSlave.h InterruptIn.h InterruptManager.h LocalFileSystem.h LowPowerTicker.h LowPowerTimeout.h LowPowerTimer.h mbed.h mbed_assert.h mbed_debug.h mbed_error.h mbed_interface.h platform.h PortIn.h PortInOut.h PortOut.h PwmOut.h RawSerial.h rtc_time.h semihost_api.h Serial.h SerialBase.h SPI.h SPISlave.h Stream.h Ticker.h Timeout.h Timer.h TimerEvent.h toolchain.h Transaction.h wait_api.h
    mbed-src/targets/hal/TARGET_Freescale/TARGET_K20XX/: analogin_api.c analogout_api.c clk_freqs.h gpio_api.c gpio_irq_api.c gpio_object.h i2c_api.c objects.h PeripheralPins.h pinmap.c port_api.c PortNames.h pwmout_api.c rtc_api.c serial_api.c sleep.c spi_api.c us_ticker.c
    mbed-src/hal/: analogin_api.h analogout_api.h buffer.h can_api.h dma_api.h ethernet_api.h gpio_api.h gpio_irq_api.h i2c_api.h lp_ticker_api.h pinmap.h port_api.h pwmout_api.h rtc_api.h serial_api.h sleep_api.h spi_api.h ticker_api.h us_ticker_api.h
    mbed-src/common/: assert.c board.c BusIn.cpp BusInOut.cpp BusOut.cpp CallChain.cpp CAN.cpp error.c Ethernet.cpp FileBase.cpp FileLike.cpp FilePath.cpp FileSystemLike.cpp gpio.c I2C.cpp I2CSlave.cpp InterruptIn.cpp InterruptManager.cpp LocalFileSystem.cpp lp_ticker_api.c mbed_interface.c pinmap_common.c RawSerial.cpp retarget.cpp rtc_time.c semihost_api.c Serial.cpp SerialBase.cpp SPI.cpp SPISlave.cpp Stream.cpp Ticker.cpp ticker_api.c Timeout.cpp Timer.cpp TimerEvent.cpp us_ticker_api.c wait_api.c
    mbed-src/targets/cmsis/TARGET_Freescale/TARGET_K20XX/TARGET_TEENSY3_1/: cmsis.h cmsis_nvic.c cmsis_nvic.h MK20DX256.h system_MK20DX256.c system_MK20DX256.h
    mbed-src/targets/cmsis/: core_ca9.h core_ca_mmu.h core_caFunc.h core_caInstr.h core_cm0.h core_cm0plus.h core_cm3.h core_cm4.h core_cm4_simd.h core_cm7.h core_cmFunc.h core_cmInstr.h core_cmSimd.h
    mbed-src/targets/hal/TARGET_Freescale/TARGET_K20XX/TARGET_TEENSY3_1/: device.h PeripheralNames.h PeripheralPins.c PinNames.h
    mbed-src/targets/cmsis/TARGET_Freescale/TARGET_K20XX/TARGET_TEENSY3_1/TOOLCHAIN_ARM_STD/: startup_MK20DX256.S sys.cpp
  group Teensy_Projet_Tomates
    ./: main.cpp mbed_config.h
  group WakeUp
    WakeUp/Device/LPC1114_WakeInterruptIn/: WakeInterruptIn.cpp WakeInterruptIn.h
    WakeUp/: WakeUp.h
    WakeUp/Device/: WakeUp_Freescale.cpp WakeUp_LPC11u24.cpp WakeUp_LPC11XX.cpp WakeUp_LPC812.cpp WakeUp_STM_RTC.cpp
